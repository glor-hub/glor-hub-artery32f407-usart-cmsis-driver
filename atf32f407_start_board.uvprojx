# Keil uVision project atf32f407_start_board.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F407VGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.8
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atf32f407_start_board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\App\0_Common;.\App\1_Variation;.\App\2_Middle;.\App\3_Driver;.\RTE;C:\Keil_v5\ARM\PACK\Keil\ArteryTek.AT32F403A_407_DFP.2.0.8\Device\Include;.\lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group 0_Common
    ./App/0_Common/: main.c app.c
  group 1_Variation
    ./App/1_Variation/: test_periph.c
  group 2_Middle
    ./App/2_Middle/: gpio.c led.c clock.c NMI-ISR.c assert.c timer.c
  group 3_Driver
    ./App/3_Driver/: arm_clock.c arm_gpio.c
  group lib
    ./lib/: at32f403a_407_def.h
software components: CMSIS:CORE 5.6.0, Device:at32f403a_407_firmware_library:crm 2.0.0, Device:at32f403a_407_firmware_library:debug 2.0.0, Device:at32f403a_407_firmware_library:gpio 2.0.0, Device:startup 2.0.0, Compiler:I/O:STDOUT 1.2.0
